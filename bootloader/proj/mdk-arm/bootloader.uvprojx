# Keil uVision project bootloader.uvprojx, settings and files
target nrf52_s132_sdk12_release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rigdfu2_nrf52_s132_sdk12_rel +hex
  AfterMake: ..\..\build-tools\make_bin.bat $P @L $P\..\..\src
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NRF52, SDK12, RELEASE, BLE_STACK_SUPPORT_REQD, SOFTDEVICE_PRESENT, S132, __HEAP_SIZE=0
  c misc: --diag_suppress=1294
  c include: ..;..\..\src;..\..\lib\crypto\headers;..\..\lib\dfu;..\..\lib\crypto\;..\..\lib\heatshrink\;..\..\lib\info;..\..\lib\patch;..\..\lib\rigado;..\..\lib\utils;..\..\nordicsemi\dfu;..\..\nordicsemi\mempool;..\..\nordicsemi\other;..\..\nordicsemi\sdk12\components\ble\ble_debug_assert_handler;..\..\nordicsemi\sdk12\components\ble\ble_services\ble_dis;..\..\nordicsemi\sdk12\components\ble\common;..\..\nordicsemi\sdk12\components\drivers_nrf\common;..\..\nordicsemi\sdk12\components\drivers_nrf\ble_flash;..\..\nordicsemi\sdk12\components\drivers_nrf\delay;..\..\nordicsemi\sdk12\components\drivers_nrf\hal;..\..\nordicsemi\sdk12\components\libraries\crc16;..\..\nordicsemi\sdk12\components\libraries\util;..\..\nordicsemi\sdk12\components\libraries\scheduler;..\..\nordicsemi\sdk12\components\libraries\bootloader;..\..\nordicsemi\sdk12\components\libraries\timer;..\..\nordicsemi\sdk12\components\device;..\..\nordicsemi\sdk12\components\softdevice\s132\headers;..\..\nordicsemi\sdk12\components\softdevice\s132\headers\nrf52;..\..\nordicsemi\sdk12\components\softdevice\common\softdevice_handler;..\..\nordicsemi\sdk12\components\drivers_nrf\config;..\..\nordicsemi\sdk12\components\ble\ble_error_log;..\..\nordicsemi\sdk12\components\libraries\ic_info;..\..\nordicsemi\sdk12\components\libraries\bootloader\dfu;..\..\nordicsemi\sdk12\components\drivers_nrf\clock;..\..\nordicsemi\sdk12\components\toolchain
  library: MicroLIB
  memory RVCT4: ROM 0x75000 size 0x9000
  memory RVCT9: RAM 0x20002c00 size 0xd400
  group crypto
    ../../lib/crypto/modes/ctr/: ctr_decrypt.c ctr_done.c ctr_encrypt.c ctr_start.c
    ../../lib/crypto/encauth/eax/: eax_decrypt.c eax_done.c eax_encrypt.c eax_init.c
    ../../lib/crypto/misc/: error_to_string.c zeromem.c
    ../../lib/crypto/: ltc_nrf.c test.c
    ../../lib/crypto/mac/omac/: omac_done.c omac_init.c omac_process.c
  group device
    ../../nordicsemi/sdk11/components/toolchain/arm/: arm_startup_nrf51.s arm_startup_nrf52.s
    ../../nordicsemi/sdk11/components/toolchain/: system_nrf51.c system_nrf52.c
  group dfu
    ../../nordicsemi/dfu/: bootloader.c dfu_transport_ble.c dfu_dual_bank.c ble_dfu.c bootloader_settings.c
    ../../lib/dfu/: dfu_transport_serial.c
  group inflate
    ../../lib/heatshrink/: heatshrink_config.h heatshrink_decoder.c
  group mempool
    ../../nordicsemi/mempool/: hci_mem_pool_ble.c
  group patch
    ../../lib/patch/: bspatch.c patcher.c
  group rigado
    ../../lib/info/: rig_firmware_info.c
    ../../lib/rigado/: rigdfu.c rigdfu_serial.c rigdfu_util.c
  group sdk10/ble
    ../../nordicsemi/sdk10/components/ble/ble_services/ble_dis/: ble_dis.c
    ../../nordicsemi/sdk10/components/ble/common/: ble_srv_common.c ble_advdata.c ble_conn_params.c
    ../../nordicsemi/sdk10/components/ble/ble_debug_assert_handler/: ble_debug_assert_handler.c
    ../../nordicsemi/sdk10/components/ble/ble_error_log/: ble_error_log.c
  group sdk10/drivers
    ../../nordicsemi/sdk10/components/drivers_nrf/delay/: nrf_delay.c
    ../../nordicsemi/sdk10/components/drivers_nrf/ble_flash/: ble_flash.c
  group sdk10/libraries
    ../../nordicsemi/sdk10/components/libraries/util/: app_error.c nrf_assert.c
    ../../nordicsemi/sdk10/components/libraries/scheduler/: app_scheduler.c
    ../../nordicsemi/sdk10/components/libraries/bootloader_dfu/: bootloader_settings.c bootloader_util.c
    ../../nordicsemi/sdk10/components/libraries/crc16/: crc16.c
    ../../nordicsemi/sdk10/components/libraries/timer/: app_timer.c
    ../../nordicsemi/sdk10/components/libraries/ic_info/: nrf51_ic_info.c
  group sdk10/softdevice
    ../../nordicsemi/sdk10/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group sdk11/ble
    ../../nordicsemi/sdk11/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../nordicsemi/sdk11/components/ble/ble_debug_assert_handler/: ble_debug_assert_handler.c
    ../../nordicsemi/sdk11/components/ble/ble_services/ble_dis/: ble_dis.c
  group sdk11/drivers
    ../../nordicsemi/sdk11/components/drivers_nrf/delay/: nrf_delay.c
    ../../nordicsemi/sdk11/components/drivers_nrf/common/: nrf_drv_common.c
    ../../nordicsemi/sdk11/components/drivers_nrf/ble_flash/: ble_flash.c
  group sdk11/libraries
    ../../nordicsemi/sdk11/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../nordicsemi/sdk11/components/libraries/scheduler/: app_scheduler.c
    ../../nordicsemi/sdk11/components/libraries/timer/: app_timer.c
    ../../nordicsemi/sdk11/components/libraries/crc16/: crc16.c
    ../../nordicsemi/sdk11/components/libraries/bootloader_dfu/: bootloader_settings.c bootloader_util.c
    ../../nordicsemi/sdk11/components/libraries/ic_info/: nrf_ic_info.c
  group sdk11/softdevice
    ../../nordicsemi/sdk11/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group sdk12/ble
    ../../nordicsemi/sdk12/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../nordicsemi/sdk12/components/ble/ble_debug_assert_handler/: ble_debug_assert_handler.c
    ../../nordicsemi/sdk12/components/ble/ble_services/ble_dis/: ble_dis.c
  group sdk12/drivers
    ../../nordicsemi/sdk12/components/drivers_nrf/common/: nrf_drv_common.c
    ../../nordicsemi/sdk12/components/drivers_nrf/ble_flash/: ble_flash.c
    ../../nordicsemi/sdk12/components/drivers_nrf/clock/: nrf_drv_clock.c
  group sdk12/libraries
    ../../nordicsemi/sdk12/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../nordicsemi/sdk12/components/libraries/scheduler/: app_scheduler.c
    ../../nordicsemi/sdk12/components/libraries/timer/: app_timer.c
    ../../nordicsemi/sdk12/components/libraries/crc16/: crc16.c
    ../../nordicsemi/sdk12/components/libraries/ic_info/: nrf_ic_info.c
    ../../nordicsemi/sdk12/components/libraries/bootloader/: nrf_bootloader_info.c nrf_bootloader_app_start.c
    ../../nordicsemi/sdk12/components/libraries/bootloader/dfu/: nrf_dfu_mbr.c
  group sdk12/softdevice
    ../../nordicsemi/sdk12/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group user
    ../../src/: main.c version.h sdk_config.h
    ../../nordicsemi/other/: simple_uart.c
  group utils
    ../../lib/utils/: fstorage.c queue.c crc32.c
  group sdk12/toolchain
    ../../nordicsemi/sdk12/components/toolchain/: system_nrf52.c system_nrf52.h
target nrf52_s132_sdk12_debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: rigdfu2_nrf52_s132_rel +hex
  AfterMake: ..\..\build-tools\make_bin.bat $P @L $P\..\..\src
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NRF52, SDK12, BLE_STACK_SUPPORT_REQD, SOFTDEVICE_PRESENT, S132, __HEAP_SIZE=0
  c misc: --diag_suppress=1294
  c include: ..;..\..\src;..\..\lib\crypto\headers;..\..\lib\dfu;..\..\lib\crypto\;..\..\lib\heatshrink\;..\..\lib\info;..\..\lib\patch;..\..\lib\rigado;..\..\lib\utils;..\..\nordicsemi\dfu;..\..\nordicsemi\mempool;..\..\nordicsemi\other;..\..\nordicsemi\sdk12\components\ble\ble_debug_assert_handler;..\..\nordicsemi\sdk12\components\ble\ble_services\ble_dis;..\..\nordicsemi\sdk12\components\ble\common;..\..\nordicsemi\sdk12\components\drivers_nrf\common;..\..\nordicsemi\sdk12\components\drivers_nrf\ble_flash;..\..\nordicsemi\sdk12\components\drivers_nrf\delay;..\..\nordicsemi\sdk12\components\drivers_nrf\hal;..\..\nordicsemi\sdk12\components\libraries\crc16;..\..\nordicsemi\sdk12\components\libraries\util;..\..\nordicsemi\sdk12\components\libraries\scheduler;..\..\nordicsemi\sdk12\components\libraries\bootloader;..\..\nordicsemi\sdk12\components\libraries\timer;..\..\nordicsemi\sdk12\components\device;..\..\nordicsemi\sdk12\components\softdevice\s132\headers;..\..\nordicsemi\sdk12\components\softdevice\s132\headers\nrf52;..\..\nordicsemi\sdk12\components\softdevice\common\softdevice_handler;..\..\nordicsemi\sdk12\components\drivers_nrf\config;..\..\nordicsemi\sdk12\components\ble\ble_error_log;..\..\nordicsemi\sdk12\components\libraries\ic_info;..\..\nordicsemi\sdk12\components\drivers_nrf\clock;..\..\nordicsemi\sdk12\components\libraries\bootloader\dfu;..\..\nordicsemi\sdk12\components\toolchain
  library: MicroLIB
  memory RVCT4: ROM 0x75000 size 0x9000
  memory RVCT9: RAM 0x20003000 size 0xc000
target nrf52_s132_release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: rigdfu2_nrf52_s132_rel +hex
  AfterMake: ..\..\build-tools\make_bin.bat $P @L $P\..\..\src
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NRF52, RELEASE, BLE_STACK_SUPPORT_REQD, SOFTDEVICE_PRESENT, S132, __HEAP_SIZE=0
  c misc: --diag_suppress=1294
  c include: ..;..\..\src;..\..\lib\crypto\headers;..\..\lib\dfu;..\..\lib\crypto\;..\..\lib\heatshrink\;..\..\lib\info;..\..\lib\patch;..\..\lib\rigado;..\..\lib\utils;..\..\nordicsemi\dfu;..\..\nordicsemi\mempool;..\..\nordicsemi\other;..\..\nordicsemi\sdk11\components\ble\ble_debug_assert_handler;..\..\nordicsemi\sdk11\components\ble\ble_services\ble_dis;..\..\nordicsemi\sdk11\components\ble\common;..\..\nordicsemi\sdk11\components\drivers_nrf\common;..\..\nordicsemi\sdk11\components\drivers_nrf\ble_flash;..\..\nordicsemi\sdk11\components\drivers_nrf\delay;..\..\nordicsemi\sdk11\components\drivers_nrf\hal;..\..\nordicsemi\sdk11\components\libraries\crc16;..\..\nordicsemi\sdk11\components\libraries\util;..\..\nordicsemi\sdk11\components\libraries\scheduler;..\..\nordicsemi\sdk11\components\libraries\bootloader_dfu;..\..\nordicsemi\sdk11\components\libraries\timer;..\..\nordicsemi\sdk11\components\device;..\..\nordicsemi\sdk11\components\softdevice\s132\headers;..\..\nordicsemi\sdk11\components\softdevice\s132\headers\nrf52;..\..\nordicsemi\sdk11\components\softdevice\common\softdevice_handler;..\..\nordicsemi\sdk11\components\drivers_nrf\config;..\..\nordicsemi\sdk11\components\ble\ble_error_log;..\..\nordicsemi\sdk11\components\libraries\ic_info
  library: MicroLIB
  memory RVCT4: ROM 0x75000 size 0x9000
  memory RVCT9: RAM 0x20002c00 size 0xd400
target nrf52_s132_debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: rigdfu2_nrf52_s132_debug +hex
  AfterMake: ..\..\build-tools\make_bin.bat $P @L $P\..\..\src
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NRF52, BLE_STACK_SUPPORT_REQD, SOFTDEVICE_PRESENT, DFU_DEBUG, CONFIG_GPIO_AS_PINRESET, S132, __HEAP_SIZE=0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x75000 size 0x9000
  memory RVCT9: RAM 0x20002800 size 0x7800
target nrf52_s332_release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: rigdfu2_nrf52_s332_rel +hex
  AfterMake: ..\..\build-tools\make_bin.bat $P @L $P\..\..\src
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NRF52, RELEASE, BLE_STACK_SUPPORT_REQD, SOFTDEVICE_PRESENT, S332, __HEAP_SIZE=0
  c misc: --diag_suppress=1294
  c include: ..;..\..\src;..\..\lib\crypto\headers;..\..\lib\dfu;..\..\lib\crypto\;..\..\lib\heatshrink\;..\..\lib\info;..\..\lib\patch;..\..\lib\rigado;..\..\lib\utils;..\..\nordicsemi\dfu;..\..\nordicsemi\mempool;..\..\nordicsemi\other;..\..\nordicsemi\sdk11\components\ble\ble_debug_assert_handler;..\..\nordicsemi\sdk11\components\ble\ble_services\ble_dis;..\..\nordicsemi\sdk11\components\ble\common;..\..\nordicsemi\sdk11\components\drivers_nrf\common;..\..\nordicsemi\sdk11\components\drivers_nrf\ble_flash;..\..\nordicsemi\sdk11\components\drivers_nrf\delay;..\..\nordicsemi\sdk11\components\drivers_nrf\hal;..\..\nordicsemi\sdk11\components\libraries\crc16;..\..\nordicsemi\sdk11\components\libraries\util;..\..\nordicsemi\sdk11\components\libraries\scheduler;..\..\nordicsemi\sdk11\components\libraries\bootloader_dfu;..\..\nordicsemi\sdk11\components\libraries\timer;..\..\nordicsemi\sdk11\components\device;..\..\nordicsemi\sdk11\components\softdevice\s332\headers;..\..\nordicsemi\sdk11\components\softdevice\s332\headers\nrf52;..\..\nordicsemi\sdk11\components\softdevice\common\softdevice_handler;..\..\nordicsemi\sdk11\components\drivers_nrf\config;..\..\nordicsemi\sdk11\components\ble\ble_error_log;..\..\nordicsemi\sdk11\components\libraries\ic_info
  library: MicroLIB
  memory RVCT4: ROM 0x75000 size 0x9000
  memory RVCT9: RAM 0x20002c00 size 0xd400
target nrf52_s332_debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: rigdfu2_nrf52_s332_debug +hex
  AfterMake: ..\..\build-tools\make_bin.bat $P @L $P\..\..\src
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NRF52, BLE_STACK_SUPPORT_REQD, SOFTDEVICE_PRESENT, S332, __HEAP_SIZE=0
  c misc: --diag_suppress=1294
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x75000 size 0x9000
  memory RVCT9: RAM 0x20002c00 size 0xd400
target nrf51_s130_release (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rigdfu2_nrf51_s130_rel +hex
  AfterMake: ..\..\build-tools\make_bin.bat $P @L $P\..\..\src
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NRF51,RELEASE, BLE_STACK_SUPPORT_REQD, SOFTDEVICE_PRESENT, S130, BSP_DEFINES_ONLY, __HEAP_SIZE=0
  c misc: --diag_suppress=1294
  c include: ..;..\..\src;..\..\lib\crypto\headers;..\..\lib\dfu;..\..\lib\crypto\;..\..\lib\heatshrink\;..\..\lib\info;..\..\lib\patch;..\..\lib\rigado;..\..\lib\utils;..\..\nordicsemi\dfu;..\..\nordicsemi\mempool;..\..\nordicsemi\other;..\..\nordicsemi\sdk11\components\ble\ble_debug_assert_handler;..\..\nordicsemi\sdk11\components\ble\ble_services\ble_dis;..\..\nordicsemi\sdk11\components\ble\common;..\..\nordicsemi\sdk11\components\drivers_nrf\common;..\..\nordicsemi\sdk11\components\drivers_nrf\ble_flash;..\..\nordicsemi\sdk11\components\drivers_nrf\delay;..\..\nordicsemi\sdk11\components\drivers_nrf\hal;..\..\nordicsemi\sdk11\components\libraries\crc16;..\..\nordicsemi\sdk11\components\libraries\util;..\..\nordicsemi\sdk11\components\libraries\scheduler;..\..\nordicsemi\sdk11\components\libraries\bootloader_dfu;..\..\nordicsemi\sdk11\components\libraries\timer;..\..\nordicsemi\sdk11\components\device;..\..\nordicsemi\sdk11\components\softdevice\s130\headers;..\..\nordicsemi\sdk11\components\softdevice\s130\headers\nrf51;..\..\nordicsemi\sdk11\components\softdevice\common\softdevice_handler;..\..\nordicsemi\sdk11\components\drivers_nrf\config;..\..\nordicsemi\sdk11\components\ble\ble_error_log;..\..\nordicsemi\sdk11\components\libraries\ic_info
  library: MicroLIB
  memory RVCT4: ROM 0x3a800 size 0x5000
  memory RVCT9: RAM 0x20002800 size 0x5800
target nrf51_s130_debug (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: rigdfu2_nrf51_s130_debug +hex
  AfterMake: ..\..\build-tools\make_bin.bat $P @L $P\..\..\src
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NRF51, BLE_STACK_SUPPORT_REQD, SOFTDEVICE_PRESENT, S130, BSP_DEFINES_ONLY, __HEAP_SIZE=0
  c misc: --diag_suppress=1294
  c include: as above
  memory RVCT4: ROM 0x38000 size 0x7800
  memory RVCT9: RAM 0x20002800 size 0x5800
target nrf51_s110_release (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: rigdfu2_nrf51_s110_rel +hex
  AfterMake: ..\..\build-tools\make_bin.bat $P @L $P\..\..\src
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NRF51,SDK10, RELEASE, BLE_STACK_SUPPORT_REQD, SOFTDEVICE_PRESENT, S110, __HEAP_SIZE=0
  c misc: --diag_suppress=1294
  c include: ..;..\..\src;..\..\lib\crypto\headers;..\..\lib\dfu;..\..\lib\crypto\;..\..\lib\heatshrink\;..\..\lib\info;..\..\lib\patch;..\..\lib\rigado;..\..\lib\utils;..\..\nordicsemi\dfu;..\..\nordicsemi\mempool;..\..\nordicsemi\other;..\..\nordicsemi\sdk10\components\ble\ble_debug_assert_handler;..\..\nordicsemi\sdk10\components\ble\ble_services\ble_dis;..\..\nordicsemi\sdk10\components\ble\common;..\..\nordicsemi\sdk10\components\drivers_nrf\common;..\..\nordicsemi\sdk10\components\drivers_nrf\ble_flash;..\..\nordicsemi\sdk10\components\drivers_nrf\delay;..\..\nordicsemi\sdk10\components\drivers_nrf\hal;..\..\nordicsemi\sdk10\components\libraries\crc16;..\..\nordicsemi\sdk10\components\libraries\util;..\..\nordicsemi\sdk10\components\libraries\scheduler;..\..\nordicsemi\sdk10\components\libraries\bootloader_dfu;..\..\nordicsemi\sdk10\components\libraries\timer;..\..\nordicsemi\sdk10\components\device;..\..\nordicsemi\sdk10\components\softdevice\s110\headers;..\..\nordicsemi\sdk10\components\softdevice\s110\headers\nrf51;..\..\nordicsemi\sdk10\components\softdevice\common\softdevice_handler;..\..\nordicsemi\sdk10\components\drivers_nrf\config;..\..\nordicsemi\sdk10\components\ble\ble_error_log;..\..\nordicsemi\sdk10\components\libraries\ic_info
  library: MicroLIB
  memory RVCT4: ROM 0x3a800 size 0x5000
  memory RVCT9: RAM 0x20002800 size 0x5800
target nrf51_s110_debug (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: rigdfu2_nrf51_s110_debug +hex
  AfterMake: ..\..\build-tools\make_bin.bat $P @L $P\..\..\src
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NRF51,SDK10, DEBUG, BLE_STACK_SUPPORT_REQD, SOFTDEVICE_PRESENT, S110, __HEAP_SIZE=0, BSP_DEFINES_ONLY
  c misc: --diag_suppress=1294
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x38000 size 0x7800
  memory RVCT9: RAM 0x20002800 size 0x5800
software components: CMSIS:CORE 4.3.0

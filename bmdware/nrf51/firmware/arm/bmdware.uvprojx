# Keil uVision project bmdware.uvprojx, settings and files
target BMDware-Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: bmdware_rel_nrf51_s110 +hex
  AfterMake: ..\..\build-tools\make_binaries.bat $P @L $P..\
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF51 SDK_OLD RELEASE BMD200 BLE_STACK_SUPPORT_REQD APP_START_ADDRESS=0x18000
  c include: ..;..\..\..\common;..\..\..\common\at;..\..\..\common\ble;..\..\..\common\lib;..\..\..\common\timeslot
  memory RVCT4: ROM 0x18000 size 0xf000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group common
    ../../../common/: bootloader_info.c crc.c gpio_ctrl.c lock.c rig_firmware_info.c rigdfu_util.c rigdfu.c ringbuf.c settings.c sys_init.c timer.c uart.c storage_intf.c
  group common/at
    ../../../common/at/: at_commands.h at_commands.c at_commands_beacon.c at_commands_gpio.c at_commands_misc.c at_commands_uart.c at_proc.c at_utils.c
  group common/ble
    ../../../common/ble/: advertising.c ble_beacon_config.c ble_nus.c gap.c
    ../../../common/: service.c
  group common/lib
    ../../../common/lib/: simple_uart.c
  group common/timeslot
    ../../../common/timeslot/: nrf_advertiser.c ts_controller.c ts_peripheral.c ts_rng.c
  group source
    ../: gpio_ctrl_def.c pstorage_platform.h sw_irq_manager.c version.h
    ./../: main.c
  group test
    ../: bmd200_dtm.c bmd200_selftest.c
target BMDware_Debug (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: bmdware_debug +hex
  AfterMake: ..\..\build-tools\make_binaries.bat $P @L $P..\
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: NRF51 BMD200 BMD_DEBUG DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD APP_START_ADDRESS=0x18000
  c include: ..
  memory RVCT4: ROM 0x18000 size 0x10c00
  memory RVCT9: RAM 0x20002000 size 0x5800
target BMDWare-Eval-Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: bmdware_rel_nrf51_s110_eval +hex
  AfterMake: ..\..\build-tools\make_binaries.bat $P @L $P..\
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF51 SDK_OLD RELEASE BLE_STACK_SUPPORT_REQD BOARD_CUSTOM BMD200_EVAL_V31 APP_START_ADDRESS=0x18000
  c include: as above
  memory RVCT4: ROM 0x18000 size 0xdc00
  memory RVCT9: RAM 0x20002000 size 0x2000
target BMDware-Eval-Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: bmdware_eval_dbg +hex
  AfterMake: ..\..\build-tools\make_binaries.bat $P @L $P..\
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: NRF51 BMD_DEBUG DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001 BMDWARE_INCLUDE_UART BMD200_EVAL_V31 APP_START_ADDRESS=0x18000
  c include: as above
  memory RVCT4: ROM 0x18000 size 0xf000
  memory RVCT9: RAM 0x20002000 size 0x2000
target BMDware-SCS001 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: scs001-rel +hex
  AfterMake: ..\..\build-tools\make_binaries.bat $P @L $P..\
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001 BMDWARE_INCLUDE_UART BMDWARE_SCS_001
  c include: ..
  memory RVCT4: ROM 0x16000 size 0x11000
  memory RVCT9: RAM 0x20002000 size 0x2000
target BMDware-Eval-Test-S120 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: bmdware_eval_test_s120 +hex
  AfterMake: ..\..\build-tools\make_binaries.bat $P @L $P..\
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001 BMDWARE_INCLUDE_UART BMD200_EVAL_V31  TEST_S120
  c include: ..
  memory RVCT4: ROM 0x1d000 size 0xe400
  memory RVCT9: RAM 0x20002800 size 0x5800
target BMDware-Eval-Test-S130 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: bmdware_eval_test_s130 +hex
  AfterMake: ..\..\build-tools\make_binaries.bat $P @L $P..\
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001 BMDWARE_INCLUDE_UART BMD200_EVAL_V31  TEST_S130
  c include: ..
  memory RVCT4: ROM 0x1b000 size 0xf400
  memory RVCT9: RAM 0x20002800 size 0x5800
software components: CMSIS:CORE 4.3.0, Device:Startup 8.3.2, nRF_BLE:BLE_Modules:ble_advdata 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_common 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_conn_params 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_debug_assert_handler 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_dtm 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_error_log 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_service_common 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_dis 4.0.0-2.alpha, nRF_Drivers:ble_flash 4.0.0-2.alpha, nRF_Drivers:nrf_delay 4.0.0-2.alpha, nRF_Drivers:nrf_drv_common 4.0.0-2.alpha, nRF_Drivers:nrf_error 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_gpiote 4.0.0-2.alpha, nRF_Drivers:pstorage 4.0.0-2.alpha, nRF_Libraries:DFU:dfu_bootloader_util 4.0.0-2.alpha, nRF_Libraries:app_error 4.0.0-2.alpha, nRF_Libraries:app_gpiote 4.0.0-2.alpha, nRF_Libraries:app_timer 4.0.0-2.alpha, nRF_Libraries:app_util 4.0.0-2.alpha, nRF_Libraries:nrf_assert 4.0.0-2.alpha, nRF_SoftDevice:Internal:sd_common 2.0.0-2.alpha, nRF_SoftDevice:Internal:softdevice_present 2.0.0-2.alpha, nRF_SoftDevice:s110 8.0.3, nRF_SoftDevice:s120 2.1.1, nRF_SoftDevice:s130 2.0.0-7.alpha
